## sim/gem5/Kconfig
```kconfig
menu "HolonNPU external devices"

config HOLON_NPU
    bool "HolonNPU programmable NPU device"
    default y

endmenu
```
